# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\ebox;..\ebox\core;..\ebox\Peripherals;..\util;..\edriver;..\network;..\fat;..\edriver\WiFi;..\user;..\other
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_code
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox
    ../ebox/core/: core.cpp sys.cpp digital.cpp analog.cpp ebox_it.cpp
    ../ebox/Peripherals/: uart.cpp i2c.cpp softi2c.cpp softspi.cpp exti.cpp pwm.cpp in_capture.cpp gtimer.cpp rtc.cpp iflash.cpp wdg.cpp dac.cpp
    ../ebox/peripherals/: spi.cpp timer_one.cpp can.cpp
    ../ebox/: object.cpp
  group util
    ../util/: util.cpp color_convert.cpp ringbuf.cpp calendar.cpp WString.cpp itoa.c dtostrf.c
  group edriver
    ../edriver/: encoder.cpp 74HC595.cpp Button.cpp DS3231.cpp LCD1602.cpp LED.cpp MPU6050.CPP w25x16.cpp w5500.cpp mmc_sd.cpp at24c02.cpp L3G4200D.cpp lsm303dhlc.cpp colorled.cpp Nokia5110.cpp FT800.cpp ws2812.cpp Max7456.cpp NRF24L01.cpp lcd_1.8.cpp OLED.cpp OLED_ssd1306.cpp LTC1446.cpp dht11.cpp ir_encoder.cpp ir_decoder.cpp at45db.cpp fm25v.cpp ultrasonic_wave.cpp
  group os
    ../os/ebox_os/: cpu.c cpu.h os.c os.h os_cpu_a.asm
  group network
    ../network/: socket.cpp dns.cpp udp.cpp tcp.cpp dhcp.cpp
  group fat
    ../fat/: wrapperdiskio.cpp diskio.c ff.c
  group WiFi
    ../edriver/WiFi/: ESP8266.cpp esp8266_tcp.cpp esp8266_udp.cpp
  group user
    ../user/: main.cpp
