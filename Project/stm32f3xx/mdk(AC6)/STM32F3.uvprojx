# Keil uVision project STM32F3.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F334R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F3 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F334x8
  c include: ..\..\..\mcuLib\stm32f3xx\Libraries\STM32F3xx_HAL_Driver\Inc;..\..\..\mcuLib\stm32f3xx\Libraries\CMSIS\Include;..\..\..\mcuLib\stm32f3xx\Libraries\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\ebox;..\..\..\ebox\core;..\..\..\ebox\hardware\STM32F3xx;..\..\..\ebox\hardware\STM32F3xx\Peripherals;..\..\..\ebox\interface;..\..\..\ebox\interface\DateTime;..\..\..\ebox\interface\event;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\spi;..\..\..\component;..\..\..\user;..\..\..\user\board\Nucleo_F334R8;..\..\..\component\edriver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../mcuLib/stm32f3xx/Libraries/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
    ../../../mcuLib/stm32f3xx/Libraries/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f334x8.s
  group Libraries
    ../../../mcuLib/stm32f3xx/Libraries/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_rcc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_exti.c stm32f3xx_ll_usart.c stm32f3xx_ll_dma.c stm32f3xx_ll_adc.c stm32f3xx_ll_tim.c stm32f3xx_ll_spi.c stm32f3xx_ll_i2c.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c myprintf.c retarge.c Dstring.cpp IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp
  group interface
    ../../../ebox/interface/DateTime/: DateTime.cpp basicRtc.cpp RtcMillis.cpp
    ../../../ebox/interface/: hmi.cpp
    ../../../ebox/interface/event/: EventVar.cpp EventManager.h
    ../../../ebox/interface/spi/: soft_spi.cpp spi.h
    ../../../ebox/interface/i2c/: soft_i2c.cpp i2c.cpp
  group interfa/File
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileHandle.cpp FileSystem.cpp FileBase.cpp FileSystemHandle.cpp
  group ebox_mcu
    ../../../ebox/hardware/STM32F3xx/: mcu.cpp rcc.cpp nvic.cpp dma.cpp ebox_it.cpp object.cpp
    ../../../ebox/hardware/STM32F3xx/Peripherals/: ebox_gpio.cpp ebox_exti.cpp ebox_uart.cpp ebox_mcu_i2c.cpp ebox_mcu_spi.cpp
  group driver
    ../../../component/OneButton/: OneButton.cpp
    ../../../component/edriver/: OLED_i2c.cpp at24x.cpp DS3231.cpp
  group user
    ../../../user/board/Nucleo_F334R8/: bsp_Nucleo_F334R8.cpp ebox_config.h mcu_config.h main.cpp
software components: CMSIS:CORE 5.6.0
