# Keil uVision project STM32F4.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: ARM_MATH_CM4
  c include: ..\..\..\mcuLib\stm32f4xx\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\mcuLib\stm32f4xx\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\ebox;..\..\..\ebox\core;..\..\..\ebox\interface;..\..\..\ebox\interface\DateTime;..\..\..\ebox\interface\spi;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\event;..\..\..\component;..\..\..\user;..\..\..\ebox\hardware\cortex-m4;..\..\..\ebox\hardware\cortex-m4\Peripherals;..\..\..\component\ddc;..\..\..\user\board\spark_f4;..\..\..\component\edriver;..\..\..\component\apps;..\..\..\component\gui;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../../mcuLib/stm32f4xx/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f427_437xx.s startup_stm32f429_439xx.s
    ../../../mcuLib/stm32f4xx/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries
    ../../../mcuLib/stm32f4xx/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c myprintf.c Dstring.cpp IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/DateTime/: DateTime.cpp basicRtc.cpp RtcMillis.cpp
    ../../../ebox/interface/: hmi.cpp
    ../../../ebox/interface/event/: EventVar.cpp EventManager.h
    ../../../ebox/interface/spi/: soft_spi.cpp
    ../../../ebox/interface/i2c/: i2c.cpp soft_i2c.cpp
  group interface/File
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileHandle.cpp FileSystem.cpp FileBase.cpp FileSystemHandle.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m4/: mcu.cpp rcc.cpp nvic.cpp dma.cpp ebox_it.cpp ebox_object.cpp
    ../../../ebox/hardware/cortex-m4/Peripherals/: ebox_gpio.cpp ebox_exti.cpp ebox_adc.cpp ebox_timer.cpp ebox_pwm.cpp ebox_uart.cpp ebox_wdg.cpp ebox_iflash.cpp ebox_dac.cpp ebox_mcu_spi.cpp ebox_mcu_i2c.cpp
    ../../../user/board/spark_f4/: mcu_config.h
  group apps
    ../../../component/apps/: color_convert.cpp
    ../../../component/edriver/: parallel_gpio.cpp
  group edriver
    ../../../component/edriver/: at24x.cpp OLED_i2c.cpp OLED_SSD1322.cpp OLED_4spi.cpp
    ../../../component/OneButton/: OneButton.cpp
  group user
    ../../../user/board/spark_f4/: main.cpp bsp_ebox.cpp FSMCIO.c bsp_ebox.h ebox_config.h mcu_config.h
  group modbus
    ../../../component/modbus/libraries/Modbus/: Modbus.cpp
    ../../../component/modbus/libraries/ModbusSerial/: ModbusSerial.cpp
software components: CMSIS:CORE 5.6.0
