# Keil uVision project STM32F3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F373VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F373xC,USE_FULL_LL
  c include: ..\..\..\mcuLib\stm32f3xx\Libraries\STM32F3xx_HAL_Driver\Inc;..\..\..\mcuLib\stm32f3xx\Libraries\CMSIS\Include;..\..\..\mcuLib\stm32f3xx\Libraries\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\ebox\core;..\..\..\ebox\core\port;..\..\..\ebox\hardware\STM32F3xx;..\..\..\ebox\hardware\STM32F3xx\Peripherals;..\..\..\user;..\..\..\user\board\stm32f373
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../mcuLib/stm32f3xx/Libraries/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f373xc.s
    ../../../mcuLib/stm32f3xx/Libraries/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Libraries
    ../../../mcuLib/stm32f3xx/Libraries/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_rcc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_exti.c stm32f3xx_ll_usart.c stm32f3xx_ll_dma.c stm32f3xx_ll_adc.c stm32f3xx_ll_tim.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c myprintf.c retarge.c Dstring.cpp IPAddress.cpp list.cpp new.cpp print.cpp ringbuf.cpp snprintf.cpp sort.cpp Stream.cpp WString.cpp
    ../../../ebox/core/port/: ebox_virtual_hmi.cpp
  group ebox_mcu
    ../../../ebox/hardware/STM32F3xx/: ebox_it.cpp mcu.cpp rcc.cpp ebox_object.cpp
    ../../../ebox/hardware/STM32F3xx/Peripherals/: ebox_gpio.cpp
  group user
    ../../../user/board/stm32f373/: bsp_ebox.cpp
    ../../../user/: main.cpp
software components: CMSIS:CORE 5.1.1
