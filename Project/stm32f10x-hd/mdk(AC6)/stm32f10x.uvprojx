# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: ARM_MATH_CM3
  c include: ..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\ebox;..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\interface;..\..\..\ebox\interface\event;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\spi;..\..\..\ebox\interface\DateTime;..\..\..\component;..\..\..\ebox\core;..\..\..\component\edriver;..\..\..\component\apps;..\..\..\component\apps\calendar;..\..\..\user;..\..\..\user\board\stm32f10x_hd;..\..\..\component\ddc;..\..\..\component\stepMotor;..\..\..\component\gui;..\..\..\component\Firmata;..\..\..\component\apps\Filters;..\..\..\component\apps\Filters\normal;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial;..\..\..\component\WeeESP8266;..\..\..\ebox\core\port;..\..\..\component\MPU6050;..\..\..\component\mqtt\src;..\..\..\os\ebox_os
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp retarge.c big_little.c crc.c ebox_mem.c fifo.c itoa.c IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp myprintf.c ebox_math.cpp list_c.c
  group interface
    ../../../ebox/interface/DateTime/: DateTime.cpp basicRtc.cpp RtcMillis.cpp
    ../../../ebox/interface/: hmi.cpp
    ../../../ebox/interface/event/: EventVar.cpp EventManager.h
    ../../../ebox/interface/spi/: soft_spi.cpp
    ../../../ebox/interface/i2c/: i2c.cpp soft_i2c.cpp
  group interface/File
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileHandle.cpp FileSystem.cpp FileBase.cpp FileSystemHandle.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: mcu.cpp rcc.cpp nvic.cpp dma.cpp ebox_it.cpp object.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_gpio.cpp ebox_uart.cpp ebox_adc.cpp ebox_can.cpp ebox_dac.cpp ebox_encoder.cpp ebox_exti.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_step_motor.cpp ebox_timer.cpp ebox_wdg.cpp ebox_mcu_i2c.cpp ebox_mcu_spi.cpp
  group edriver
    ../../../component/edriver/: DS3231.cpp parallel_gpio.cpp OLED_i2c.cpp OLED_4spi.cpp w25xxx.cpp mmc_sd.cpp
    ../../../component/OneButton/: OneButton.cpp
  group network
    ../../../component/Ethernet3/utility/: socket.cpp w5500.cpp
    ../../../component/Ethernet3/: Dhcp.cpp Dns.cpp Ethernet3.cpp EthernetClient.cpp EthernetServer.cpp EthernetUdp3.cpp
  group user
    ../../../user/board/stm32f10x_hd/: main.cpp bsp_ebox.cpp ebox_config.h mcu_config.h
  group mqtt
    ../../../component/mqtt/src/: PubSubClient.cpp
  group os
    ../../../os/ebox_os/: cpu.c os.c os_cpu_a.asm
  group mpu6050
    ../../../component/MPU6050/: FourAxle.cpp IMU.cpp MPU6050.CPP
  group Fs
    ../../../ebox/interface/storage/filesystem/fat/: FATFileSystem.cpp
    ../../../ebox/interface/storage/filesystem/fat/ChaN/: ff.cpp ffunicode.cpp
software components: CMSIS:CORE 5.6.0
