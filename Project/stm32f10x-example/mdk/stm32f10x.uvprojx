# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __CC_ARM,ARM_MATH_CM3
  c include: ..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\core;..\..\..\ebox\core\port;..\..\..\component;..\..\..\component\edriver;..\..\..\component\apps;..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\user;..\..\..\user\board\spark_f1;..\..\..\component\ddc;..\..\..\component\stepMotor;..\..\..\component\cnc;..\..\..\component\network;..\..\..\component\gui;..\..\..\component\Firmata;..\..\..\component\apps\Filters;..\..\..\component\apps\Filters\normal;..\..\..\component\DSP_Lib;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial;..\..\..\component\uGUI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c IPAddress.cpp list.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp myprintf.c snprintf.cpp
    ../../../ebox/core/port/: ebox_virtual_hmi.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: mcu.cpp rcc.cpp object.cpp dma.cpp nvic.cpp ebox_it.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_gpio.cpp ebox_uart.cpp ebox_adc.cpp ebox_can.cpp ebox_dac.cpp ebox_encoder.cpp ebox_exti.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_softi2c.cpp ebox_softspi.cpp ebox_spi.cpp ebox_step_motor.cpp ebox_timer.cpp ebox_wdg.cpp
  group user
    ../../../user/: main.cpp ads1271.cpp
    ../../../user/board/spark_f1/: bsp_ebox.cpp
  group app
    ../../../component/apps/: EventGpio.cpp EventIo.cpp
  group modbus
    ../../../component/modbus/libraries/Modbus/: Modbus.cpp
    ../../../component/modbus/libraries/ModbusSerial/: ModbusSerial.cpp
  group example
    ../../../example/1.digital/: 1.gpio_write.cpp 2.button.cpp
    ../../../example/5.uart/: 1.helloWorld.cpp A1.new_test.cpp
    ../../../example/core/: core_cpuClock.cpp core_Systick.cpp core_SystickMultipe.cpp
    ../../../example/4.exti/: gpio_exti.cpp
    ../../../example/10.i2c/: I2C_search address.cpp 1.24c02.cpp
    ../../../example/7.wdg/: 1.iwdg.cpp
    ../../../example/32.内部flash读写/: 2.flash_f04.cpp 1.flash_test.cpp
    ../../../example/9.spi/: 3.ltc1446.cpp
    ../../../example/8.rtc/: rtc_calendar F0.cpp 3.calendar.cpp
    ../../../example/20.显示器类/3.tft_1.8/: 1.lcd_frame_rate.cpp
    ../../../example/16.gui/: 4.uGUI_BaseTest.cpp
  group dDriver
    ../../../component/edriver/: at24c02.cpp LTC1446.cpp lcd_1.8.cpp
  group uGUI
    ../../../component/uGUI/: ugui.c
software components: CMSIS:CORE 5.1.1
