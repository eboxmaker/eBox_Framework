# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\mcuLib\N32G030\CMSIS\core;..\..\..\mcuLib\N32G030\CMSIS\device;..\..\..\mcuLib\N32G030\n32g030_std_periph_driver\inc;..\..\..\ebox\core;..\..\..\ebox\hardware\n32g030;..\..\..\ebox\hardware\n32g030\Peripherals;..\..\..\ebox\interface;..\..\..\ebox\interface\spi;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\TwoWire;..\..\..\ebox\interface\event;..\..\..\ebox\interface\DateTime;..\..\..\user;..\..\..\user\board\N32G030
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../mcuLib/N32G030/CMSIS/device/: system_n32g030.c
    ../../../mcuLib/N32G030/CMSIS/device/startup/: startup_n32g030.s
  group libraries
    ../../../mcuLib/N32G030/n32g030_std_periph_driver/src/: misc.c n32g030_adc.c n32g030_beeper.c n32g030_comp.c n32g030_crc.c n32g030_dbg.c n32g030_dma.c n32g030_exti.c n32g030_flash.c n32g030_gpio.c n32g030_hdiv.c n32g030_i2c.c n32g030_iwdg.c n32g030_lptim.c n32g030_lpuart.c n32g030_opamp.c n32g030_pwr.c n32g030_rcc.c n32g030_rtc.c n32g030_spi.c n32g030_sqrt.c n32g030_tim.c n32g030_usart.c n32g030_wwdg.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp myprintf.c retarge.cpp list_c.c ebox_math.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/DateTime/: DateTime.cpp basicRtc.cpp RtcMillis.cpp
    ../../../ebox/interface/: hmi.cpp
    ../../../ebox/interface/event/: EventVar.cpp EventManager.h
    ../../../ebox/interface/i2c/: i2c.cpp soft_i2c.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
  group interface/file
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileHandle.cpp FileSystem.cpp FileSystemHandle.cpp FileBase.cpp
  group ebox_mcu
    ../../../ebox/hardware/n32g030/: mcu.cpp rcc.cpp nvic.cpp dma.cpp ebox_it.cpp object.cpp
    ../../../ebox/hardware/n32g030/Peripherals/: ebox_gpio.cpp ebox_exti.cpp ebox_uart.cpp ebox_mcu_i2c.cpp ebox_mcu_spi.cpp ebox_timer.cpp
  group user
    ../../../user/board/N32G030/: bsp_ebox.cpp main.cpp bsp_ebox.h ebox_config.h mcu_config.h
software components: CMSIS:CORE 5.5.0
