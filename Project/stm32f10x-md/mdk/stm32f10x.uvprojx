# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\core;..\..\..\component;..\..\..\component\edriver;..\..\..\component\apps;..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\user;..\..\..\user\board\spark_f1;..\..\..\component\ddc;..\..\..\component\stepMotor;..\..\..\component\gui;..\..\..\component\Firmata;..\..\..\component\apps\Filters;..\..\..\component\apps\Filters\normal;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial;..\..\..\component\WeeESP8266;..\..\..\ebox\core\port;..\..\..\component\MPU6050;..\..\..\component\mqtt\src;..\..\..\os\ebox_os;..\..\..\component\Ethernet3;..\..\..\component\Ethernet3\utility;..\..\..\component\modbus\libraries\ModbusIP;..\..\..\component\soft_uart;..\..\..\component\Firmata;..\..\..\component\Firmata\utility;..\..\..\component\arducat\libraries\arducat;..\..\..\component\fat
  memory RVCT4: ROM 0x8000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c IPAddress.cpp list.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp myprintf.c retarge.c
    ../../../ebox/core/port/: ebox_virtual_hmi.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: mcu.cpp rcc.cpp nvic.cpp dma.cpp ebox_it.cpp object.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_gpio.cpp ebox_uart.cpp ebox_adc.cpp ebox_can.cpp ebox_dac.cpp ebox_encoder.cpp ebox_exti.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_softi2c.cpp ebox_softspi.cpp ebox_spi.cpp ebox_step_motor.cpp ebox_timer.cpp ebox_wdg.cpp
  group edriver
    ../../../component/edriver/: DS3231.cpp w25x16.cpp Max7456.cpp LTC1446.cpp OLED_SSD1322.cpp GT30L32S4W.cpp ds18b20.cpp mmc_sd.cpp at24c02.cpp lcd_1.8.cpp parallel_gpio.cpp
    ../../../component/ir/: ir_decoder.cpp ir_encoder.cpp
  group app
    ../../../component/apps/: EventGpio.cpp EventVar.cpp EventManager.h
    ../../../component/edriver/: ebox_virtual_lcd.cpp
  group user
    ../../../user/: main.cpp ui_main.cpp ui.cpp ui_setValue.cpp ui_menu.cpp ui_password.cpp
    ../../../user/board/spark_f1/: bsp_ebox.cpp ebox_config.h
  group mqtt
    ../../../component/mqtt/src/: PubSubClient.cpp
  group os
    ../../../os/ebox_os/: cpu.c os.c os_cpu_a.asm
  group fat
    ../../../component/fat/: diskio.c ff.c wrapperdiskio.cpp
  group gui
    ../../../component/gui/: Font8_ASCII.cpp Font16_ASCII.cpp Font16_HZ.cpp Font24_ASCII.cpp Font32_ASCII.cpp FontCustom.cpp gui_bitmap.cpp gui_sidebar.cpp gui_text.cpp graphic.cpp gui_button.cpp gui_base.cpp gui_page.cpp gui_list.cpp gui_menu.cpp gui_textview.cpp
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
