# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=1
  c include: ..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\ebox\core;..\..\..\ebox\core\LinkedList;..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\interface\DateTime;..\..\..\ebox\interface\event;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\spi;..\..\..\user\board\spark_f1;..\..\..\component\Ethernet3;..\..\..\component\Ethernet3\utility
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../ebox/core/: big_little.c crc.c ebox_mem.c fifo.c itoa.c myprintf.c retarge.c Dstring.cpp ebox_core.cpp ebox_init.cpp ebox_math.cpp IPAddress.cpp new.cpp print.cpp sort.cpp Stream.cpp WString.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/DateTime/: basicRtc.cpp DateTime.cpp RtcMillis.cpp
    ../../../ebox/interface/event/: EventVar.cpp
    ../../../ebox/interface/i2c/: i2c.cpp soft_i2c.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: dma.cpp ebox_it.cpp mcu.cpp nvic.cpp object.cpp rcc.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_adc.cpp ebox_can.cpp ebox_dac.cpp ebox_encoder.cpp ebox_exti.cpp ebox_gpio.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_mcu_i2c.cpp ebox_mcu_spi.cpp ebox_pulse.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_timer.cpp ebox_uart.cpp ebox_wdg.cpp
  group user
    ../../../user/board/spark_f1/: bsp_ebox.h ebox_config.h mcu_config.h bsp_ebox.cpp main.cpp
  group eth
    ../../../component/Ethernet3/: Dhcp.cpp Dns.cpp Ethernet3.cpp EthernetClient.cpp EthernetServer.cpp EthernetUdp3.cpp
    ../../../component/Ethernet3/utility/: socket.cpp w5500.cpp
software components: CMSIS:CORE 5.6.0
