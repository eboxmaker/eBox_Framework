# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\..\ebox;..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\core;..\..\..\ebox\interface;..\..\..\ebox\interface\spi;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\TwoWire;..\..\..\ebox\interface\event;..\..\..\ebox\interface\DateTime;..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\component;..\..\..\component\edriver;..\..\..\component\apps;..\..\..\user;..\..\..\user\board\spark_f1;..\..\..\component\ddc;..\..\..\component\stepMotor;..\..\..\component\gui;..\..\..\component\Firmata;..\..\..\component\apps\Filters;..\..\..\component\apps\Filters\normal;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial;..\..\..\component\WeeESP8266;..\..\..\component\MPU6050;..\..\..\component\mqtt\src;..\..\..\os\ebox_os;..\..\..\component\Ethernet3;..\..\..\component\Ethernet3\utility;..\..\..\component\modbus\libraries\ModbusIP;..\..\..\component\fat;..\..\..\component\littlefs;..\..\..\component\pn532;..\..\..\os\FreeRTOS\Cfg;..\..\..\os\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\os\FreeRTOS\Source\include;..\..\..\component\linearRegression;..\..\..\component\ArduinoJson;..\..\..\component\display;..\..\..\ebox\interface\painter;..\..\..\os\rtt\components\cplusplus
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp myprintf.c retarge.cpp ebox_math.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/DateTime/: DateTime.cpp basicRtc.cpp RtcMillis.cpp
    ../../../ebox/interface/: hmi.cpp
    ../../../ebox/interface/event/: EventVar.cpp EventManager.h
    ../../../ebox/interface/i2c/: i2c.cpp soft_i2c.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
  group interface/file
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileHandle.cpp FileSystem.cpp FileSystemHandle.cpp FileBase.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: mcu.cpp rcc.cpp nvic.cpp dma.cpp ebox_it.cpp object.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_gpio.cpp ebox_uart.cpp ebox_adc.cpp ebox_can.cpp ebox_dac.cpp ebox_encoder.cpp ebox_exti.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_step_motor.cpp ebox_timer.cpp ebox_wdg.cpp ebox_pulse.cpp ebox_mcu_i2c.cpp ebox_mcu_spi.cpp
  group user
    ../: mian.cpp
    ../../../user/board/spark_f1/: bsp_ebox.cpp ebox_config.h mcu_config.h
  group cpp
    ../../../os/rtt/components/cplusplus/: cxx_crt.cpp cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp cxx_crt_init.c
software components: CMSIS:CORE 5.5.0, RTOS:device 3.1.5, RTOS:kernel 3.1.5
