# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\..\ebox\hardware\cortex-m3;..\..\..\ebox\hardware\cortex-m3\Peripherals;..\..\..\ebox\core;..\..\..\ebox\core\mem;..\..\..\component;..\..\..\component\edriver;..\..\..\component\apps;..\..\..\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\..\..\mcuLib\stm32f10x\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\component\lwip\lwip-2.0.2\src\include;..\..\..\component\lwip;..\..\..\component\lwip\ebox
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_code
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libraries
    ../../../mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ebox_core
    ../../../ebox/core/: itoa.c big_little.cpp ebox_core.cpp list.cpp new.cpp print.cpp ringbuf.cpp util.cpp WString.cpp fifo.c ebox_printf.cpp
    ../../../ebox/core/mem/: ebox_mem.c
    ../../../ebox/core/math/: crc.c random.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m3/: mcu_core.cpp mcu_mem.c ebox_it.cpp object.cpp
    ../../../ebox/hardware/cortex-m3/Peripherals/: ebox_analog.cpp ebox_can.cpp ebox_dac.cpp ebox_encoder.cpp ebox_exti.cpp ebox_gpio.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_softi2c.cpp ebox_softspi.cpp ebox_spi.cpp ebox_timer.cpp ebox_uart.cpp ebox_wdg.cpp
  group edriver
    ../../../component/edriver/: 74HC595.cpp ADS7816.cpp ADS8866.cpp AM2315.cpp at24c02.cpp at45db.cpp BMP280-3.3.cpp Button.cpp colorled.cpp dht11.cpp ds18b20.cpp DS3231.cpp enc28j60.cpp encoder.cpp fm25v.cpp GP2Y1051.cpp INA219.cpp ir_decoder.cpp ir_encoder.cpp key_dm.cpp L3G4200D.cpp lcd_1.8.cpp LCD1602.cpp LED.cpp led_segment.cpp lsm303dhlc.cpp LTC1446.cpp LTC2943.cpp Max7456.cpp MCP23017.cpp mmc_sd.cpp MPU6050.CPP Nokia5110.cpp NRF24L01.cpp OLED_4spi.cpp OLED_i2c.cpp parallel_gpio.cpp PCA9685.cpp si4432.cpp sx1278.cpp TingATCmd.cpp TLC59711.cpp TM1637.cpp TM1638.cpp TSL2561.cpp ultrasonic_wave.cpp USR_GM3.cpp w25x16.cpp w5500.cpp ws2812.cpp WS2812B.cpp
  group app
    ../../../component/apps/: calendar.cpp color_convert.cpp EventGpio.cpp EventIo.cpp
  group user
    ../../../user/: bsp.cpp main.cpp
