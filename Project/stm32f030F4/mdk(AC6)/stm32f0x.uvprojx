# Keil uVision project stm32f0x.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=1
  c define: USE_FULL_LL_DRIVER,STM32F030x6
  c include: ..\..\..\mcuLib\stm32f0xx\Libraries\CMSIS\Include;..\..\..\mcuLib\stm32f0xx\Libraries\STM32F0xx_HAL_Driver\Inc;..\..\..\mcuLib\stm32f0xx\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\ebox\core;..\..\..\ebox\core\port;..\..\..\ebox\hardware\cortex-m0;..\..\..\ebox\hardware\cortex-m0\Peripherals;..\..\..\ebox\interface;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\spi;..\..\..\user;..\..\..\user\board\stm32f030f4;..\..\..\component\edriver;..\..\..\ebox\hardware\cortex-m0\mcu;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group start_code
    ../../../mcuLib/stm32f0xx/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s startup_stm32f030x6.s
  group CMSIS
    ../../../mcuLib/stm32f0xx/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group libraries_LL
    ../../../mcuLib/stm32f0xx/Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_utils.c stm32f0xx_ll_rcc.c stm32f0xx_ll_gpio.c stm32f0xx_ll_exti.c stm32f0xx_ll_usart.c stm32f0xx_ll_dma.c stm32f0xx_ll_adc.c stm32f0xx_ll_tim.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c myprintf.c Dstring.cpp IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/DateTime/: DateTime.cpp basicRtc.cpp RtcMillis.cpp
    ../../../ebox/interface/i2c/: soft_i2c.cpp i2c.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
    ../../../ebox/interface/event/: EventVar.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m0/: mcu.cpp rcc.cpp nvic.cpp dma.cpp object.cpp ebox_it.cpp
    ../../../ebox/hardware/cortex-m0/Peripherals/: ebox_gpio.cpp ebox_uart.cpp ebox_exti.cpp ebox_i2c.cpp ebox_adc.cpp ebox_wdg.cpp ebox_iflash.cpp ebox_timer.cpp ebox_pwm.cpp ebox_in_capture.cpp ebox_spi.cpp ebox_rtc.cpp
  group user
    ../../../user/board/stm32f030f4/: main.cpp bsp_ebox.cpp ebox_config.h bsp_ebox.h mcu_config.h
  group 说明
    ../: 说明.txt
software components: CMSIS:CORE 5.6.0
